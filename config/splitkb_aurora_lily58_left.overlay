#include "splitkb_aurora_lily58.dtsi"

/ {
    /* THIS only makes keymap binding happy, nothing happens on peripheral side */
	mouse_ps21: virtual_input {
		compatible = "zmk,virtual-input";
	};
};